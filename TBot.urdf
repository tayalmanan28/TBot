Commit message: Added TBot URDF

File: TBot.urdf (robot description, URDF)
Before this commit: robot T_bot, 14 links, 13 joints
Links:
- removed link planeLink
Joints:
- removed joint Free
